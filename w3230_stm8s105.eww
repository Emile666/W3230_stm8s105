<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\w3230_stm8s105.ewp</path>
    </project>
    <batchBuild />
</workspace>
